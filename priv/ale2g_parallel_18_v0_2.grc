<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ale2g_parallel_18_v0_2</value></param>
<param><key>author</key><value>Devin Butterfield / K6DRS</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>ALE2G Parallel V0.2 8-channels</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_01AHFN</value></param>
<param><key>value</key><value>1843000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_01BHFL</value></param>
<param><key>value</key><value>1996000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_03AHFN</value></param>
<param><key>value</key><value>3596000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_03BHFL</value></param>
<param><key>value</key><value>3791000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_03CHFL</value></param>
<param><key>value</key><value>3996000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_05AHFN</value></param>
<param><key>value</key><value>5357000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_05BHFL</value></param>
<param><key>value</key><value>5360000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_05CHFL</value></param>
<param><key>value</key><value>5371500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_07AHFN</value></param>
<param><key>value</key><value>7102000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_07BHFL</value></param>
<param><key>value</key><value>7185500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_07CHFL</value></param>
<param><key>value</key><value>7296000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_10AHFN</value></param>
<param><key>value</key><value>10145500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_14AHFN</value></param>
<param><key>value</key><value>14109000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_14BHFL</value></param>
<param><key>value</key><value>14346000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_18AHFN</value></param>
<param><key>value</key><value>18106000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_18BHFL</value></param>
<param><key>value</key><value>18117500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_21AHFN</value></param>
<param><key>value</key><value>21096000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ale_chan_21BHFL</value></param>
<param><key>value</key><value>21432500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_bpf_voice</value></param>
<param><key>comment</key><value>Fs=8kHz 3dB BW = 300 to 2700, transition 500, stop 60dB, Gain=1</value></param>
<param><key>value</key><value>[0.0018120616441592574, -0.0, 0.002514434279873967, 0.002985243685543537, -0.0007079992210492492, 0.004741193726658821, 0.00411085644736886, -0.005856884177774191, 0.005198285914957523, 7.730309708315301e-18, -0.02186439372599125, 2.2320216478296047e-17, -0.014062493108212948, -0.05356903001666069, -0.00827835313975811, -0.036448944360017776, -0.10315141081809998, 2.437763634611959e-17, -0.05780387297272682, -0.20961540937423706, 0.1960151046514511, 0.5997917056083679, 0.1960151046514511, -0.20961540937423706, -0.05780387297272682, 2.437763634611959e-17, -0.10315141081809998, -0.036448944360017776, -0.00827835313975811, -0.05356903001666069, -0.014062493108212948, 2.2320216478296047e-17, -0.02186439372599125, 7.730309708315301e-18, 0.005198285914957523, -0.005856884177774191, 0.00411085644736886, 0.004741193726658821, -0.0007079992210492492, 0.002985243685543537, 0.002514434279873967, 0.0, 0.0018120616441592574]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_usb_taps</value></param>
<param><key>comment</key><value>Fs=32kHz 3dB BW = 150 to 3050, transition 200, stop 40dB, taps=291 Gain=4 (or 6)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[(-1.5617657167510401e-10+0.0003000458236783743j), (-3.420600842218846e-05+0.00010527503764024004j), (5.3523941460298374e-05-7.366926001850516e-05j), (0.00023515100474469364-0.00017084687715396285j), (0.00045011710608378053-0.00014625140465795994j), (0.0006247111596167088+7.248316391539333e-10j), (0.0006964643253013492+0.0002262959606014192j), (0.0006357940146699548+0.00046193276648409665j), (0.0004576295323204249+0.000629875052254647j), (0.00021862037829123437+0.0006728481967002153j), (-1.033643615144797e-09+0.0005742385401390493j), (-0.0001190532639157027+0.00036640590406022966j), (-8.914427598938346e-05+0.00012269604485481977j), (8.991221693577245e-05-6.532474799314514e-05j), (0.000365360698197037-0.00011871194874402136j), (0.0006460321601480246+1.5761779659229092e-09j), (0.0008316012681461871+0.00027020598645322025j), (0.0008475545328110456+0.0006157879251986742j), (0.000673994654789567+0.0009276795899495482j), (0.0003574656439013779+0.0011001770617440343j), (-3.292984551706013e-09+0.0010693103540688753j), (-0.00027283019153401256+0.0008396758348681033j), (-0.00035525840939953923+0.0004889678675681353j), (-0.0002015752688748762+0.00014645193004980683j), (0.00015172141138464212-4.929667557007633e-05j), (0.0005915964720770717+2.200323701018192e-09j), (0.0009625843958929181+0.0003127667005173862j), (0.0011195873375982046+0.000813434598967433j), (0.0009818295948207378+0.001351384213194251j), (0.0005683086928911507+0.0017490994650870562j), (-8.12824207940821e-09+0.0018646793905645609j), (-0.0005351793370209634+0.0016470873961225152j), (-0.000845095724798739+0.00116316310595721j), (-0.0008035908685997128+0.0005838371580466628j), (-0.0004027404065709561+0.00013085611863061786j), (0.00023352791322395205+1.167362539966632e-09j), (0.0008830390870571136+0.0002869218005798757j), (0.0012980805477127433+0.0009431211510673165j), (0.0012939508305862546+0.001780990744009614j), (0.0008221582393161952+0.0025303903967142105j), (-1.652373349259051e-08+0.0029304821509867907j), (-0.0009182730573229492+0.0028260983526706696j), (-0.0016228152671828866+0.0022335860412567854j), (-0.0018571809632703662+0.001349303754977882j), (-0.0015166827943176031+0.0004927897825837135j), (-0.0006994124851189554-4.391142116588753e-09j), (0.00031286932062357664+0.00010165962157770991j), (0.0011427196441218257+0.0008302458445541561j), (0.0014472060138359666+0.001991936005651951j), (0.0010459598852321506+0.003219207748770714j), (-2.8303121624162486e-08+0.004091177135705948j), (-0.0013916591415181756+0.004282983485609293j), (-0.0026822793297469616+0.003691784804686904j), (-0.0034291951451450586+0.002491417806595564j), (-0.0033554157707840204+0.0010902131907641888j), (-0.002463257871568203-1.8616921337866188e-08j), (-0.0010546429548412561-0.00034268322633579373j), (0.0003563502978067845+0.0002589078794699162j), (0.001214782358147204+0.0016720324056223035j), (0.0011236893478780985+0.0034584549721330404j), (-4.108087381382575e-08+0.005011327564716339j), (-0.0018726977286860347+0.005763407796621323j), (-0.003920406103134155+0.005395879969000816j), (-0.005466781556606293+0.003971777856349945j), (-0.005971168167889118+0.0019400926539674401j), (-0.005234354175627232-4.62578775284328e-08j), (-0.0034947036765515804-0.0011355327442288399j), (-0.0013721369905397296-0.00099693494848907j), (0.0003301809774711728+0.00045446393778547645j), (0.0009042196907103062+0.00278299069032073j), (-4.931782981998367e-08+0.005203884560614824j), (-0.0022236842196434736+0.006843572948127985j), (-0.005121973343193531+0.007049647159874439j), (-0.007765044923871756+0.005641518626362085j), (-0.009255044162273407+0.0030070440843701363j), (-0.00905273761600256-9.158542724208019e-08j), (-0.007195984944701195-0.002338198944926262j), (-0.004323966801166534-0.003141614142805338j), (-0.0014856947818771005-0.0020449284929782152j), (0.0002119545970344916+0.0006523527554236352j), (-4.3570206997856076e-08+0.0040505426004529j), (-0.0022535044699907303+0.006935316603630781j), (-0.005954283755272627+0.008195177651941776j), (-0.009949661791324615+0.007228683214634657j), (-0.012907864525914192+0.004193858243525028j), (-0.013786406256258488-1.5711529499640164e-07j), (-0.012226120568811893-0.003972663078457117j), (-0.008724188432097435-0.006338648963719606j), (-0.0045098233968019485-0.006207393016666174j), (-0.0011485079303383827-0.0035348867531865835j), (-9.700931613565444e-09+0.0008059829124249518j), (-0.0017158602131530643+0.005280656274408102j), (-0.005959515925496817+0.008202358148992062j), (-0.011463917791843414+0.008328806608915329j), (-0.016427205875515938+0.005337294656783342j), (-0.019125960767269135-2.4243891516562144e-07j), (-0.018539665266871452-0.006024164613336325j), (-0.014762971550226212-0.010726219043135643j), (-0.00904424674808979-0.012448680587112904j), (-0.0034125125966966152-0.010503104887902737j), (7.299230730950512e-08-0.005481686908751726j), (-0.00028280323022045195+0.0008703389903530478j), (-0.004507727455347776+0.006204177625477314j), (-0.011520406231284142+0.008369823917746544j), (-0.019085122272372246+0.006200839765369892j), (-0.02461319975554943-3.434876418850763e-07j), (-0.0260674599558115-0.008470237255096436j), (-0.022731363773345947-0.01651579514145851j), (-0.015558854676783085-0.021415570750832558j), (-0.00695109274238348-0.021394317969679832j), (2.383172414965884e-07-0.016328487545251846j), (0.002570915501564741-0.00791206769645214j), (-0.0005920242401771247+0.0008148259366862476j), (-0.008881956338882446+0.006452915724366903j), (-0.01979963295161724+0.0064329602755606174j), (-0.029700452461838722-4.5248458491187193e-07j), (-0.03500818833708763-0.011375444009900093j), (-0.033500511199235916-0.02434033714234829j), (-0.025216473266482353-0.03470863774418831j), (-0.012634635902941227-0.038887493312358856j), (5.590454748016782e-07-0.035216134041547775j), (0.008037279359996319-0.0247348565608263j), (0.00803967285901308-0.0110652856528759j), (-0.0008712771814316511+0.00063299824250862j), (-0.016454488039016724+0.005346089135855436j), (-0.03383096307516098-5.586999236584234e-07j), (-0.04694143682718277-0.015253061428666115j), (-0.05056757479906082-0.03674079105257988j), (-0.042274344712495804-0.05818771570920944j), (-0.023598451167345047-0.07263277471065521j), (1.2833074833906721e-06-0.07481005042791367j), (0.020547064021229744-0.0632336437702179j), (0.02997656725347042-0.041257694363594055j), (0.02291730046272278-0.016649778932332993j), (-0.0010656111408025026+0.000346217246260494j), (-0.036525968462228775-6.499420237560116e-07j), (-0.07293258607387543-0.023698680102825165j), (-0.09713533520698547-0.07057562470436096j), (-0.09691223502159119-0.13339336216449738j), (-0.06463626772165298-0.19894230365753174j), (4.566296865959885e-06-0.250960111618042j), (0.08908901363611221-0.27417078614234924j), (0.18772727251052856-0.25837454199790955j), (0.27728065848350525-0.2014484703540802j), (0.33974283933639526-0.11038229614496231j), (0.36213579773902893+6.605002454307396e-06j), (0.3397388160228729+0.110394686460495j), (0.2772733271121979+0.20145858824253082j), (0.18771784007549286+0.2583813965320587j), (0.08907901495695114+0.2741740345954895j), (-4.588236606650753e-06+0.250960111618042j), (-0.06464352458715439+0.19893993437290192j), (-0.09691711515188217+0.13338981568813324j), (-0.09713789075613022+0.07057210803031921j), (-0.07293345034122467+0.023696035146713257j), (-0.036525968462228775-6.737453190908127e-07j), (-0.0010655985679477453-0.0003462558379396796j), (0.022916695103049278+0.01665060967206955j), (0.029975073412060738+0.041258782148361206j), (0.02054477296769619+0.06323438882827759j), (-1.427780603080464e-06+0.07481005042791367j), (-0.02360108308494091+0.07263191789388657j), (-0.04227645695209503+0.058186180889606476j), (-0.05056890845298767+0.036738958209753036j), (-0.04694198817014694+0.015251358970999718j), (-0.03383096307516098-6.673214443253528e-07j), (-0.016454294323921204-0.00534668518230319j), (-0.0008712542476132512-0.000633029849268496j), (0.008039272390305996+0.011065577156841755j), (0.008036383427679539+0.02473514713346958j), (-7.171739753175643e-07+0.035216134041547775j), (-0.01263604499399662+0.038887035101652145j), (-0.025217732414603233+0.034707725048065186j), (-0.03350139036774635+0.02433912456035614j), (-0.03500859811902046+0.011374175548553467j), (-0.029700452461838722-6.238486776055652e-07j), (-0.019799400120973587-0.006433677859604359j), (-0.008881722576916218-0.00645323796197772j), (-0.0005919946706853807-0.0008148474153131247j), (0.0025706286542117596+0.007912160828709602j), (-3.5342100090929307e-07+0.016328487545251846j), (-0.006951868534088135+0.021394064649939537j), (-0.01555962860584259+0.02141500636935234j), (-0.02273196168243885+0.01651497185230255j), (-0.026067765429615974+0.008469292894005775j), (-0.02461319975554943-5.484855023496493e-07j), (-0.01908489689230919-0.006201531738042831j), (-0.011520103551447392-0.008370241150259972j), (-0.004507502540946007-0.006204341072589159j), (-0.00028277168166823685-0.0008703492349013686j), (-1.2566195550789416e-07+0.005481686908751726j), (-0.0034128930419683456+0.010502981022000313j), (-0.009044698439538479+0.012448351830244064j), (-0.0147633608430624+0.010725683532655239j), (-0.018539883196353912+0.006023493129760027j), (-0.019125960767269135-4.506787263380829e-07j), (-0.016427012160420418-0.005337890237569809j), (-0.011463616043329239-0.008329221978783607j), (-0.005959218367934227-0.008202573284506798j), (-0.0017156688263639808-0.005280718207359314j), (1.9507584880784634e-08-0.0008059829124249518j), (-0.0011486359871923923+0.003534845309332013j), (-0.004510048311203718+0.006207229569554329j), (-0.00872441753745079+0.0063383327797055244j), (-0.012226264923810959+0.003972220234572887j), (-0.013786406256258488-3.42498879035702e-07j), (-0.012907711789011955-0.0041943262331187725j), (-0.009949399158358574-0.007229043636471033j), (-0.0059539866633713245-0.008195393718779087j), (-0.0022532532457262278-0.00693539809435606j), (1.0321993926254436e-07-0.0040505426004529j), (0.00021197821479290724-0.0006523450720123947j), (-0.0014857687056064606+0.002044874709099531j), (-0.0043240804225206375+0.003141457447782159j), (-0.007196069695055485+0.002337937941774726j), (-0.00905273761600256-2.3648237856832566e-07j), (-0.009254936128854752-0.003007379360496998j), (-0.007764840964227915-0.005641799885779619j), (-0.005121717695146799-0.007049832493066788j), (-0.002223436487838626-0.0068436539731919765j), (1.3926899100624723e-07-0.005203884560614824j), (0.0009043205645866692-0.002782957861199975j), (0.0003301974502392113-0.00045445194700732827j), (-0.001372173079289496+0.0009968852391466498j), (-0.0034947446547448635+0.0011354059679433703j), (-0.005234354175627232-1.4343314092002402e-07j), (-0.005971097853034735-0.0019403089536353946j), (-0.005466638132929802-0.003971976228058338j), (-0.003920210525393486-0.005396021995693445j), (-0.0018724888795986772-0.005763475317507982j), (1.4052774588435568e-07-0.005011327564716339j), (0.001123814727179706-0.0034584144596010447j), (0.001214842894114554-0.001671988400630653j), (0.0003563596692401916-0.00025889495736919343j), (-0.0010546554112806916+0.00034264501300640404j), (-0.002463257871568203-7.065062135325206e-08j), (-0.0033553761895745993-0.001090334728360176j), (-0.003429104806855321-0.002491542138159275j), (-0.0026821454521268606-0.0036918818950653076j), (-0.0013915038434788585-0.004283033777028322j), (1.1995959425803449e-07-0.004091177135705948j), (0.0010460765333846211-0.0032191697973757982j), (0.0014472781913354993-0.001991883385926485j), (0.001142749679274857-0.0008302044006995857j), (0.0003128729877062142-0.00010164828563574702j), (-0.0006994124851189554-2.0955303270397962e-08j), (-0.0015166649827733636-0.0004928447888232768j), (-0.001857134629972279-0.001349367550574243j), (-0.0016227386659011245-0.0022336416877806187j), (-0.0009181759669445455-0.002826129784807563j), (8.408638763057752e-08-0.0029304821509867907j), (0.0008222450851462781-0.0025303622242063284j), (0.0012940119486302137-0.001780946273356676j), (0.001298113027587533-0.0009430765639990568j), (0.000883048924151808-0.0002868914743885398j), (0.00023352791322395205+6.85018219925837e-09j), (-0.0004027359245810658-0.0001308699429500848j), (-0.0008035708451643586-0.0005838647484779358j), (-0.0008450557943433523-0.0011631922097876668j), (-0.0005351227591745555-0.0016471057897433639j), (5.5890446049033926e-08-0.0018646793905645609j), (0.0005683687049895525-0.001749080023728311j), (0.0009818760445341468-0.001351350569166243j), (0.001119615277275443-0.0008133961819112301j), (0.0009625951643101871-0.0003127336676698178j), (0.0005915964720770717+1.811052996458784e-08j), (0.00015171972336247563+4.930188515572809e-05j), (-0.00020157023391220719-0.00014645885676145554j), (-0.0003552416164893657-0.0004889800329692662j), (-0.00027280134963802993-0.0008396852063015103j), (3.34188712258765e-08-0.0010693103540688753j), (0.0003575033915694803-0.0011001648381352425j), (0.0006740264943800867-0.0009276564233005047j), (0.0008475757203996181-0.0006157588213682175j), (0.0008316105231642723-0.0002701774355955422j), (0.0006460321601480246+2.0603577510769355e-08j), (0.00036535662366077304+0.00011872449977090582j), (8.990997594082728e-05+6.532783299917355e-05j), (-8.914006320992485e-05-0.00012269910075701773j), (-0.00011904069106094539-0.0003664099785964936j), (1.86812716407303e-08-0.0005742385401390493j), (0.00021864348673261702-0.0006728406879119575j), (0.00045765115646645427-0.0006298593943938613j), (0.0006358098471537232-0.0004619109386112541j), (0.0006964720669202507-0.000226272051804699j), (0.0006247111596167088+2.07229238213813e-08j), (0.0004501120711211115+0.00014626684424001724j), (0.00023514512577094138+0.0001708549534669146j), (5.3521413065027446e-05+7.367110083578154e-05j), (-3.420239590923302e-05-0.00010527621634537354j), (1.0145079443191207e-08-0.0003000458236783743j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_usb_taps_0</value></param>
<param><key>comment</key><value>Fs=32kHz 3dB BW = 300 to 3050, transition 500, stop 60dB, taps=175 Gain=10</value></param>
<param><key>value</key><value>[(0.0027534516993910074-0.0009699877118691802j), (0.0027984913904219866-2.7479556592879817e-05j), (0.002360810060054064+0.00077990343561396j), (0.0015852131182327867+0.0011999736307188869j), (0.0007375333807431161+0.001092153019271791j), (0.0001305434270761907+0.00048089533811435103j), (2.7843039788422175e-05-0.00043571810238063335j), (0.0005513789947144687-0.0013311404036357999j), (0.0016222791746258736-0.001843751990236342j), (0.0029602961149066687-0.0016962244408205152j), (0.004152807407081127-0.0008048593299463391j), (0.004782168660312891+0.0006614730227738619j), (0.0045765177346765995+0.0023036508355289698j), (0.003532964503392577+0.0036030602641403675j), (0.001961905974894762+0.0040960186161100864j), (0.0004210577462799847+0.003557684598490596j), (-0.0004557551583275199+0.0021269710268825293j), (-0.0001881249772850424+0.0003138624597340822j), (0.0013414869317784905-0.0011343793012201786j), (0.0037830134388059378-0.0014806066174060106j), (0.006377127952873707-0.000281859771348536j), (0.008180954493582249+0.002394299488514662j), (0.00840039923787117+0.005916353315114975j), (0.006716689560562372+0.009244933724403381j), (0.003479177597910166+0.011270305141806602j), (-0.00033090790384449065+0.01122765988111496j), (-0.0033858928363770247+0.009040611796081066j), (-0.004472110886126757+0.005449141841381788j), (-0.0029722631443291903+0.0018414802616462111j), (0.0008136758697219193-0.00018690538126975298j), (0.005655196961015463+0.0005851133028045297j), (0.009732664562761784+0.0044869957491755486j), (0.011249654926359653+0.010710894130170345j), (0.009116974659264088+0.0174676813185215j), (0.003455801634117961+0.022536933422088623j), (-0.004295370075851679+0.024050896987318993j), (-0.011760447174310684+0.021242840215563774j), (-0.016407759860157967+0.014870581217110157j), (-0.016486315056681633+0.007114690262824297j), (-0.011779874563217163+0.0009268784779123962j), (-0.00387182692065835-0.000990139553323388j), (0.004236443899571896+0.002771037630736828j), (0.009084612131118774+0.011641266755759716j), (0.007995015010237694+0.023056933656334877j), (0.00016236530791502446+0.03318708762526512j), (-0.012834062799811363+0.03821635618805885j), (-0.027351530268788338+0.03576507791876793j), (-0.038809794932603836+0.02593102678656578j), (-0.043289657682180405+0.011522861197590828j), (-0.03905987739562988-0.0026890826411545277j), (-0.02745700255036354-0.011531739495694637j), (-0.012722577899694443-0.011305872350931168j), (-0.0007470044074580073-0.0013186876894906163j), (0.0029308623634278774+0.015530806966125965j), (-0.00479168351739645+0.033429861068725586j), (-0.02317208983004093+0.04547644406557083j), (-0.047478482127189636+0.04609925299882889j), (-0.07029653340578079+0.03324682638049126j), (-0.08396077901124954+0.009518826380372047j), (-0.08333911746740341-0.018286077305674553j), (-0.06799081712961197-0.041208039969205856j), (-0.04284537956118584-0.05117538943886757j), (-0.016997158527374268-0.04406467452645302j), (-0.0008509386680088937-0.021662907674908638j), (-0.002472452586516738+0.008296702057123184j), (-0.02437339909374714+0.034248534590005875j), (-0.06193532049655914+0.04453490301966667j), (-0.10422011464834213+0.03161374852061272j), (-0.13714809715747833-0.004715736489742994j), (-0.14818614721298218-0.056329261511564255j), (-0.13106486201286316-0.10864532738924026j), (-0.08887110650539398-0.14502765238285065j), (-0.034241918474435806-0.1524932086467743j), (0.013760599307715893-0.1269146203994751j), (0.03543386608362198-0.07587811350822449j), (0.017255716025829315-0.017946647480130196j), (-0.042398009449243546+0.021865131333470345j), (-0.13063979148864746+0.019377216696739197j), (-0.22176052629947662-0.040728043764829636j), (-0.2831699550151825-0.15858665108680725j), (-0.2841959595680237-0.3166787028312683j), (-0.20535197854042053-0.4823295474052429j), (-0.04535046964883804-0.6148901581764221j), (0.17637498676776886-0.6758753061294556j), (0.42268723249435425-0.6393532752990723j), (0.6467890739440918-0.49965900182724j), (0.8033024072647095-0.27414149045944214j), (0.8594496846199036+9.2208947535255e-06j), (0.8032965064048767+0.2741587162017822j), (0.6467783451080322+0.49967288970947266j), (0.4226734936237335+0.6393623352050781j), (0.17636047303676605+0.6758790612220764j), (-0.045363668352365494+0.6148892045021057j), (-0.20536231994628906+0.48232513666152954j), (-0.2842027544975281+0.3166726231575012j), (-0.2831733524799347+0.15858057141304016j), (-0.22176140546798706+0.0407232828438282j), (-0.13063937425613403-0.01938001997768879j), (-0.04239754006266594-0.02186604216694832j), (0.017255332320928574+0.017947018146514893j), (0.03543223813176155+0.07587887346744537j), (0.013757876120507717+0.12691490352153778j), (-0.034245189279317856+0.1524924784898758j), (-0.0888742208480835+0.14502575993537903j), (-0.1310671865940094+0.10864251852035522j), (-0.14818735420703888+0.05632608383893967j), (-0.1371481865644455+0.004712793510407209j), (-0.10421943664550781-0.031615983694791794j), (-0.06193436682224274-0.044536229223012924j), (-0.024372665211558342-0.03424905613064766j), (-0.0024722747039049864-0.008296755142509937j), (-0.0008514035725966096+0.021662889048457146j), (-0.016998082399368286+0.044064316898584366j), (-0.042846452444791794+0.05117449164390564j), (-0.06799168139696121+0.041206613183021545j), (-0.08333950489759445+0.018284328281879425j), (-0.08396058529615402-0.009520587511360645j), (-0.07029583305120468-0.03324830159544945j), (-0.04747750982642174-0.046100251376628876j), (-0.023171136155724525-0.04547693207859993j), (-0.004790981765836477-0.033429961651563644j), (0.002931188326328993-0.01553074549883604j), (-0.0007470321143046021+0.0013186719734221697j), (-0.01272281538695097+0.011305605061352253j), (-0.02745724655687809+0.011531163938343525j), (-0.03905993327498436+0.0026882633101195097j), (-0.0432894192636013-0.011523768305778503j), (-0.03880925104022026-0.025931838899850845j), (-0.02735077776014805-0.035765647888183594j), (-0.012833261862397194-0.03821662440896034j), (0.00016306160250678658-0.03318708389997482j), (0.007995499297976494-0.023056767880916595j), (0.009084857068955898-0.011641076765954494j), (0.004236502107232809-0.0027709484566003084j), (-0.003871847642585635+0.000990058295428753j), (-0.011779855005443096-0.0009271256276406348j), (-0.016486166045069695-0.007115036249160767j), (-0.016407446935772896-0.014870925806462765j), (-0.011760001070797443-0.021243086084723473j), (-0.004294865299016237-0.024050988256931305j), (0.0034562747459858656-0.022536862641572952j), (0.009117341600358486-0.01746748946607113j), (0.01124988030642271-0.010710657574236393j), (0.009732759557664394-0.004486791789531708j), (0.005655209068208933-0.000584994675591588j), (0.0008136719116009772+0.00018692246521823108j), (-0.0029722244944423437-0.0018415427766740322j), (-0.004471996799111366-0.005449235439300537j), (-0.0033857033122330904-0.009040683507919312j), (-0.0003306723665446043-0.011227666400372982j), (0.0034794139210134745-0.011270231567323208j), (0.006716882809996605-0.009244793094694614j), (0.008400523103773594-0.005916176829487085j), (0.008181004785001278-0.002394127892330289j), (0.006377121899276972+0.0002819935907609761j), (0.003782982472330332+0.0014806861290708184j), (0.001341463066637516+0.0011344074737280607j), (-0.00018811839981935918-0.0003138663887511939j), (-0.0004557105421554297-0.0021269803401082754j), (0.00042113239760510623-0.003557675750926137j), (0.001961992122232914-0.004095977637916803j), (0.003533039940521121-0.003602985991165042j), (0.004576565697789192-0.0023035546764731407j), (0.00478218263015151-0.0006613726727664471j), (0.004152790643274784+0.0008049464668147266j), (0.0029602604918181896+0.0016962866066023707j), (0.0016222404083237052+0.0018437860999256372j), (0.0005513510550372303+0.001331151812337339j), (2.7833899366669357e-05+0.00043571871356107295j), (0.00013055351155344397-0.0004808926023542881j), (0.000737556314561516-0.001092137536033988j), (0.001585238380357623-0.0011999404523521662j), (0.0023608263581991196-0.0007798539591021836j), (0.0027984909247606993+2.7538271751836874e-05j), (0.002753431210294366+0.0009700455120764673j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_usb_taps_voice</value></param>
<param><key>comment</key><value>Fs=32kHz 3dB BW = 150 to 2750, transition 350, stop 60dB, taps=333 Gain=1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[(0.00015185101074166596-2.1003383153583854e-05j), (0.00014625053154304624+2.1694262613891624e-05j), (0.0001207360764965415+5.566003528656438e-05j), (8.24042217573151e-05+7.179069507401437e-05j), (4.2094772652490065e-05+6.575826409971341e-05j), (1.1506571354402695e-05+3.931718674721196e-05j), (1.066107056437068e-24+3.236327086013587e-19j), (1.1931142580579035e-05-4.076891127624549e-05j), (4.525371332420036e-05-7.069401908665895e-05j), (9.182075154967606e-05-7.999545778147876e-05j), (0.00013938431220594794-6.425809260690585e-05j), (0.00017483386909589171-2.593538556538988e-05j), (0.00018785065913107246+2.5981438739108853e-05j), (0.00017398977070115507+7.814673881512135e-05j), (0.00013629431487061083+0.00011640421143965796j), (8.489148603985086e-05+0.000129786814795807j), (3.4544973459560424e-05+0.00011387522681616247j), (7.127579237931059e-07+7.251588249346241e-05j), (-4.875300874118693e-06+1.7287302398472093e-05j), (2.2112139049568214e-05-3.5302065953146666e-05j), (7.680472481297329e-05-6.825221498729661e-05j), (0.0001458626938983798-6.899042637087405e-05j), (0.00021073379321023822-3.338015085319057e-05j), (0.0002526884782128036+3.242218735977076e-05j), (0.00025830554659478366+0.00011298017489025369j), (0.00022383552277460694+0.00018739815277513117j), (0.0001570657332194969+0.00023505650460720062j), (7.593196642119437e-05+0.00024172906705643982j), (4.015948888991261e-06+0.00020430551376193762j), (-3.5994427889818326e-05+0.00013260621926747262j), (-2.9112445190548897e-05+4.7509383875876665e-05j), (2.687292180780787e-05-2.4357235815841705e-05j), (0.00011970740888500586-5.806551416753791e-05j), (0.00022514826559927315-3.7934674764983356e-05j), (0.0003132107958663255+3.706350616994314e-05j), (0.0003566293162293732+0.0001518293283879757j), (0.00033918654662556946+0.00027834909269586205j), (0.00026141354464925826+0.00038301738095469773j), (0.00014174581156112254+0.0004362097242847085j), (1.242695543623995e-05+0.00042142445454373956j), (-8.9031491370406e-05+0.00034122553188353777j), (-0.00013063092774245888+0.00021795860084239393j), (-9.585810039425269e-05+8.861550304573029e-05j), (1.019610499497503e-05-5.070090992376208e-06j), (0.00016069864796008915-2.8702210329356603e-05j), (0.000313415948767215+3.3968757634283975e-05j), (0.0004221313283778727+0.0001748366776155308j), (0.0004501068324316293+0.00036203261697664857j), (0.00038171876803971827+0.0005476510268636048j), (0.00022865449136588722+0.0006808298639953136j), (2.8419051886885427e-05+0.0007226700545288622j), (-0.00016496407624799758+0.0006586730596609414j), (-0.0002958453551400453+0.0005048027378506958j), (-0.0003233925672248006+0.00030490561039187014j), (-0.00023478787625208497+0.00011964157602051273j), (-5.101443821331486e-05+9.629785381548572e-06j), (0.00017701333854347467+1.742728090903256e-05j), (0.0003814927476923913+0.00015363149577751756j), (0.0004966964479535818+0.0003915311535820365j), (0.00047861336497589946+0.0006724829436279833j), (0.000319467595545575+0.0009211419383063912j), (5.244822386885062e-05+0.001066676340997219j), (-0.0002554087550379336+0.0010640580439940095j), (-0.0005208569345995784+0.0009091007523238659j), (-0.0006680446676909924+0.0006423703161999583j), (-0.0006514661945402622+0.00034007345675490797j), (-0.00047140195965766907+9.379041875945404e-05j), (-0.00017678088624961674-1.5652260117349215e-05j), (0.00014618657587561756+5.7208257203456014e-05j), (0.00039713759906589985+0.0003067736397497356j), (0.0004903316730633378+0.0006748136947862804j), (0.00038089833105914295+0.001064371783286333j), (8.062610868364573e-05+0.0013659890973940492j), (-0.0003420277207624167+0.0014892438193783164j), (-0.000778676476329565+0.0013905969681218266j), (-0.001110561890527606+0.0010890825651586056j), (-0.0012429654598236084+0.0006644644890911877j), (-0.0011345919920131564+0.00023735128343105316j), (-0.0008129473426379263-6.393533112714067e-05j), (-0.0003703255788423121-0.0001407423260388896j), (5.9547492128331214e-05+4.507098128669895e-05j), (0.0003384660230949521+0.00045631409739144146j), (0.0003641819639597088+0.0009869823697954416j), (0.00010260637645842507+0.0014894313644617796j), (-0.0003981966874562204+0.0018153925193473697j), (-0.0010173990158364177+0.001859545591287315j), (-0.0015927576459944248+0.0015929513610899448j), (-0.001965947914868593+0.0010759247234091163j), (-0.0020293297711759806+0.00044538124348036945j), (-0.0017604697495698929-0.00012106310168746859j), (-0.0012335615465417504-0.0004549957229755819j), (-0.0006030936492606997-0.0004472245345823467j), (-6.299791857600212e-05-8.321142377099022e-05j), (0.00020808195404242724+0.0005473113851621747j), (0.00010009975812863559+0.0012708072317764163j), (-0.000392243848182261+0.0018761508399620652j), (-0.0011620805598795414+0.0021744552068412304j), (-0.002015455160290003+0.002055704826489091j), (-0.0027233483269810677+0.001525396597571671j), (-0.0030868728645145893+0.0007093427702784538j), (-0.0029972530901432037-0.0001765442284522578j), (-0.0024727133568376303-0.0008845513220876455j), (-0.0016601935494691133-0.0012060177978128195j), (-0.0007994488696567714-0.001034676330164075j), (-0.00015796648222021759-0.0004035135789308697j), (4.5847624278394505e-05+0.0005171000375412405j), (-0.0002906174922827631+0.001461606821976602j), (-0.0011176449479535222+0.0021416659001260996j), (-0.0022391960956156254+0.0023292589467018843j), (-0.0033620570320636034+0.0019267876632511616j), (-0.004176163114607334+0.001002948498353362j), (-0.004444350488483906-0.0002179946459364146j), (-0.004075867589563131-0.0014130378840491176j), (-0.0031612426973879337-0.00224933004938066j), (-0.0019561629742383957-0.0024809923488646746j), (-0.0008161900914274156-0.0020260594319552183j), (-9.85643346211873e-05-0.0009999648900702596j), (-5.785355097032152e-05+0.00030667477403767407j), (-0.0007655196241103113+0.0015026961918920279j), (-0.0020782179199159145+0.002204718766734004j), (-0.003666896605864167+0.0021495732944458723j), (-0.005101781338453293+0.0012783334823325276j), (-0.005971800070255995-0.0002341886138310656j), (-0.006005761679261923-0.002016292652115226j), (-0.005160147789865732-0.0035958571825176477j), (-0.0036459912080317736-0.004531990736722946j), (-0.0018833144567906857-0.00454578036442399j), (-0.00039187134825624526-0.0036121183075010777j), (0.0003540665202308446-0.001983541762456298j), (6.705722626065835e-05-0.0001348887599306181j), (-0.001257235766388476+0.0013602674007415771j), (-0.003319632261991501+0.0019900365732610226j), (-0.005583775695413351+0.001457495498470962j), (-0.00741582503542304-0.0002179454022552818j), (-0.008262129500508308-0.00268387608230114j), (-0.007816233672201633-0.005333556327968836j), (-0.006126367952674627-0.0074639213271439075j), (-0.0036082370206713676-0.008473096415400505j), (-0.0009525924106128514-0.008043555542826653j), (0.0010536779882386327-0.006257294211536646j), (0.0017482145922258496-0.0036049499176442623j), (0.0007957533234730363-0.0008781016222201288j), (-0.0016865974757820368+0.0010337095009163022j), (-0.005123213864862919+0.0013911275891587138j), (-0.00860449019819498-0.00016837594739627093j), (-0.011117848567664623-0.00349127477966249j), (-0.011829371564090252-0.007902959361672401j), (-0.010341569781303406-0.012350225821137428j), (-0.006853274069726467-0.015664979815483093j), (-0.0021682369988411665-0.016887405887246132j), (0.0024642508942633867-0.015565482899546623j), (0.005649539176374674-0.011947031132876873j), (0.006221447139978409-0.007002179976552725j), (0.0035974939819425344-0.002253761747851968j), (-0.0019795200787484646+0.0005584265454672277j), (-0.009386884979903698-9.152540587820113e-05j), (-0.016785599291324615-0.005090619903057814j), (-0.021980779245495796-0.014374854974448681j), (-0.02290678210556507-0.026816731318831444j), (-0.018129294738173485-0.04035577550530434j), (-0.0072457375936210155-0.05235907807946205j), (0.008917205967009068-0.060142870992422104j), (0.028367215767502785-0.06154416874051094j), (0.04827076569199562-0.055414531379938126j), (0.06547725200653076-0.041920941323041916j), (0.07713363319635391-0.0225793719291687j), (0.0812566727399826-5.48258731214446e-06j), (0.07713668048381805+0.0225689634680748j), (0.06548290699720383+0.04191210865974426j), (0.04827824607491493+0.055408015847206116j), (0.028375521302223206+0.06154033914208412j), (0.008925322443246841+0.0601416677236557j), (-0.007238671649247408+0.05236005410552025j), (-0.018123848363757133+0.04035821929574013j), (-0.022903161123394966+0.026819823309779167j), (-0.021978840231895447+0.014377820305526257j), (-0.01678491197526455+0.0050928848795592785j), (-0.009386871941387653+9.279211371904239e-05j), (-0.0019795955158770084-0.0005581594305112958j), (0.0035977980587631464+0.0022532762959599495j), (0.006222391501069069+0.007001339923590422j), (0.005651151295751333+0.011946268379688263j), (0.002466358710080385+0.015565149486064911j), (-0.002165950136259198+0.01688770018517971j), (-0.006851152516901493+0.01566590741276741j), (-0.010339897125959396+0.012351625598967075j), (-0.011828300543129444+0.00790456123650074j), (-0.011117375455796719+0.003492780262604356j), (-0.00860446784645319+0.0001695411920081824j), (-0.005123401992022991-0.0013904336374253035j), (-0.0016867374069988728-0.0010334812104701996j), (0.0007958722417242825+0.000877993821632117j), (0.00174870272167027+0.0036047131288796663j), (0.0010545252589508891+0.006257151253521442j), (-0.0009515031124465168+0.00804368406534195j), (-0.0036070896312594414+0.008473585359752178j), (-0.0061253574676811695+0.00746475113555789j), (-0.007815510965883732+0.005334615241736174j), (-0.008261766284704208+0.0026849950663745403j), (-0.007415795233100653+0.00021894965902902186j), (-0.0055839731357991695-0.0014567392645403743j), (-0.003319901879876852-0.001989586977288127j), (-0.001257419935427606-0.0013600970851257443j), (6.707549619022757e-05+0.00013487969408743083j), (0.00035433514858596027+0.001983493799343705j), (-0.0003913821710739285+0.0036121713928878307j), (-0.0018826986197382212+0.004546035546809435j), (-0.0036453776992857456+0.004532484337687492j), (-0.005159660708159208+0.003596555907279253j), (-0.006005488336086273+0.002017105696722865j), (-0.005971768405288458+0.00023499732196796685j), (-0.005101954564452171-0.0012776426738128066j), (-0.0036671876441687346-0.0021490766666829586j), (-0.002078516408801079-0.002204437041655183j), (-0.0007657230598852038-0.00150259246584028j), (-5.789508577436209e-05-0.0003066669451072812j), (-9.842891449807212e-05+0.0009999781614169478j), (-0.0008159157005138695+0.0020261697936803102j), (-0.001955826999619603+0.0024812573101371527j), (-0.0031609381549060345+0.0022497582249343395j), (-0.004075676202774048+0.0014135899255052209j), (-0.004444320686161518+0.00021859651315025985j), (-0.004176299087703228-0.001002382836304605j), (-0.0033623180352151394-0.0019263323629274964j), (-0.0022395113483071327-0.0023289555683732033j), (-0.001117934938520193-0.0021415145602077246j), (-0.00029081542743369937-0.0014615674735978246j), (4.57775968243368e-05-0.0005171062657609582j), (-0.00015791182522661984+0.0004035349702462554j), (-0.0007993087056092918+0.001034784596413374j), (-0.0016600301023572683+0.0012062425957992673j), (-0.0024725934490561485+0.0008848861907608807j), (-0.0029972291085869074+0.00017695011047180742j), (-0.0030869687907397747-0.0007089247228577733j), (-0.0027235548477619886-0.0015250277938321233j), (-0.002015733625739813-0.002055431716144085j), (-0.0011623749742284417-0.0021742978133261204j), (-0.0003924978955183178-0.0018760977545753121j), (9.992766717914492e-05-0.0012708207359537482j), (0.00020800784113816917-0.0005473395576700568j), (-6.298665539361537e-05+8.321995119331405e-05j), (-0.0006030330550856888+0.00044730622903443873j), (-0.001233499962836504+0.00045516277896240354j), (-0.0017604533350095153+0.00012130150571465492j), (-0.002029390074312687-0.0004451064160093665j), (-0.0019660936668515205-0.001075658481568098j), (-0.001592973480001092-0.0015927356434985995j), (-0.0010176509385928512-0.0018594077555462718j), (-0.0003984425566159189-0.0018153386190533638j), (0.00010240467236144468-0.001489445217885077j), (0.00036404829006642103-0.0009870317298918962j), (0.0003384042647667229-0.00045635990682058036j), (5.954138396191411e-05-4.5079046685714275e-05j), (-0.00037030651583336294+0.00014079247193876654j), (-0.0008129386696964502+6.404542364180088e-05j), (-0.0011346241226419806-0.00023719764431007206j), (-0.0012430553324520588-0.000664296152535826j), (-0.0011107093887403607-0.0010889321565628052j), (-0.000778864836320281-0.0013904914958402514j), (-0.0003422294103074819-0.0014891976024955511j), (8.044111746130511e-05-0.001365999924018979j), (0.00038075417978689075-0.0010644233552739024j), (0.0004902402870357037-0.0006748800515197217j), (0.00039709603879600763-0.00030682742362841964j), (0.00014617883425671607-5.72280514461454e-05j), (-0.00017677877622190863+1.5676199836889282e-05j), (-0.0004714146489277482-9.37265795073472e-05j), (-0.0006515122950077057-0.00033998521394096315j), (-0.0006681316299363971-0.0006422798614948988j), (-0.0005209799855947495-0.0009090302628464997j), (-0.0002555528189986944-0.001064023468643427j), (5.230377064435743e-05-0.0010666833259165287j), (0.00031934285652823746-0.000921185128390789j), (0.00047852229909040034-0.00067254772875458j), (0.0004966434207744896-0.000391598412534222j), (0.00038147190934978426-0.00015368315507657826j), (0.00017701096658129245-1.7451253370381892e-05j), (-5.10157406097278e-05-9.622876859793905e-06j), (-0.00023480408708564937-0.00011960978008573875j), (-0.0003234332543797791-0.00030486242030747235j), (-0.0002959127305075526-0.0005047632730565965j), (-0.0001650520134717226-0.0006586510571651161j), (2.832256541296374e-05-0.0007226738962344825j), (0.00022856358555145562-0.0006808603648096323j), (0.0003816456301137805-0.000547702016774565j), (0.00045005849096924067-0.00036209268728271127j), (0.0004221079871058464-0.00017489303718321025j), (0.00031341140856966376-3.4010601666523144e-05j), (0.0001607024751137942+2.868075534934178e-05j), (1.019678165903315e-05+5.068729478807654e-06j), (-9.586993837729096e-05-8.860270463628694e-05j), (-0.00013066004612483084-0.00021794116764795035j), (-8.907705341698602e-05-0.0003412136575207114j), (1.2370689546514768e-05-0.00042142608435824513j), (0.0001416875747963786-0.0004362286417745054j), (0.0002613624092191458-0.0003830522473435849j), (0.0003391493810340762-0.0002783943491522223j), (0.0003566090308595449-0.0001518769422546029j), (0.00031320584821514785-3.710532473633066e-05j), (0.00022515332966577262+3.790461414610036e-05j), (0.00011971516505582258+5.804952888865955e-05j), (2.6876172341872007e-05+2.435364694974851e-05j), (-2.911878800659906e-05-4.750549851451069e-05j), (-3.6012130294693634e-05-0.00013260141713544726j), (3.988671323895687e-06-0.00020430605218280107j), (7.589968299726024e-05-0.00024173919518943876j), (0.00015703435929026455-0.00023507745936512947j), (0.00022381049348041415-0.000187428027857095j), (0.0002582904708106071-0.00011301466292934492j), (0.00025268414174206555-3.245592597522773e-05j), (0.0002107382460962981+3.335201108711772e-05j), (0.00014587190526071936+6.897094863234088e-05j), (7.681383431190625e-05+6.824196316301823e-05j), (2.2116853870102204e-05+3.5299115552334115e-05j), (-4.877609171671793e-06-1.7286653019255027e-05j), (7.030760116322199e-07-7.25159770809114e-05j), (3.452977034612559e-05-0.00011387983249733225j), (8.487415470881388e-05-0.0001297981507377699j), (0.00013627877342514694-0.00011642240860965103j), (0.00017397933697793633-7.816997094778344e-05j), (0.0001878471957752481-2.6006518965004943e-05j), (0.00017483733245171607+2.5912042474374175e-05j), (0.00013939289783593267+6.423948070732877e-05j), (9.183143265545368e-05+7.998319779289886e-05j), (4.5263153879204765e-05+7.068797276588157e-05j), (1.1936584996874444e-05+4.0767317841527984e-05j), (-4.214352124345747e-23-3.236327086013587e-19j), (1.1501321750984062e-05-3.9318721974268556e-05j), (4.208599420962855e-05-6.576388113899156e-05j), (8.239463932113722e-05-7.180169632192701e-05j), (0.00012072864774381742-5.5676151532679796e-05j), (0.0001462476357119158-2.1713787646149285e-05j), (0.00015185381926130503+2.0983108697691932e-05j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_usb_taps_voice_0</value></param>
<param><key>comment</key><value>Fs=32kHz 3dB BW = 300 to 2700, transition 500, stop 60dB Gain=1</value></param>
<param><key>value</key><value>[(0.0002572417724877596-0.0001374986459268257j), (0.0002878009108826518-5.724696529796347e-05j), (0.0002794687170535326+2.7525682526174933e-05j), (0.0002341329090995714+9.69816610449925e-05j), (0.00016318418784067035+0.00013392265827860683j), (8.561440336052328e-05+0.0001281321165151894j), (2.4158369342330843e-05+7.964085671119392e-05j), (1.5657680039299833e-24-2.7651913754854074e-19j), (2.7038107873522677e-05-8.913061174098402e-05j), (0.00010708856279961765-0.00016026681987568736j), (0.0002275083534186706-0.00018670817371457815j), (0.00036241410998627543-0.0001501130172982812j), (0.0004778926959261298-4.7063575038919225e-05j), (0.0005404878174886107+0.0001075157051673159j), (0.0005270802648738027+0.00028173805912956595j), (0.0004334399418439716+0.00043345062294974923j), (0.00027858378598466516+0.0005212101386860013j), (0.00010282055882271379+0.0005169517244212329j), (-4.1051407606573775e-05+0.00041673853411339223j), (-0.00010186673898715526+0.00024591718101873994j), (-4.605679350788705e-05+5.611847882391885e-05j), (0.00012920450535602868-8.632845128886402e-05j), (0.00039022479904815555-0.0001183656495413743j), (0.0006713600596413016+1.2773153201806053e-08j), (0.0008901174878701568+0.0002700334880501032j), (0.000969712738879025+0.0006479704170487821j), (0.0008632044191472232+0.0010518638882786036j), (0.0005719668697565794+0.0013809375232085586j), (0.00015198890469036996+0.0015435363166034222j), (-0.0002956545795314014+0.001486169290728867j), (-0.0006494069239124656+0.0012148822424933314j), (-0.0008014018530957401+0.0008013606420718133j), (-0.0006920106243342161+0.0003698637883644551j), (-0.0003342635463923216+6.647997361142188e-05j), (0.0001806020736694336+1.7792548533179797e-05j), (0.0007005393272265792+0.00029019438079558313j), (0.0010506140533834696+0.0008622625027783215j), (0.001082494854927063+0.0016201590187847614j), (0.000721967255230993+0.00238022836856544j), (-7.547473046543018e-08+0.0029352258425205946j), (-0.0009444224997423589+0.0031130569986999035j), (-0.001892301719635725+0.00283187348395586j), (-0.0026011615991592407+0.0021346076391637325j), (-0.0028738845139741898+0.0011903169797733426j), (-0.0026223137974739075+0.0002582088636700064j), (-0.001905573415569961-0.0003790916525758803j), (-0.0009290410671383142-0.0004966125125065446j), (1.235710951624978e-18+1.235772162990307e-18j), (0.0005516125820577145+0.0010320557048544288j), (0.0004677253891713917+0.0023517159279435873j), (-0.00035426291287876666+0.0035959919914603233j), (-0.001814499613828957+0.004380288999527693j), (-0.0036179320886731148+0.0044082454405725j), (-0.00533935846760869+0.0035674595274031162j), (-0.006533329375088215+0.001981693087145686j), (-0.006861571222543716-1.6342895037269045e-07j), (-0.00620273919776082-0.001881740870885551j), (-0.004710869863629341-0.0031478635501116514j), (-0.002800307935103774-0.0034123484510928392j), (-0.001053818967193365-0.0025443120393902063j), (-7.231748895719647e-05-0.0007344266632571816j), (-0.0003032041131518781+0.0015241260407492518j), (-0.001894141430966556+0.003543493337929249j), (-0.0046166121028363705+0.004616400692611933j), (-0.00788835994899273+0.00421618577092886j), (-0.010898937471210957+0.0021676768083125353j), (-0.01281407568603754-0.0012623675866052508j), (-0.013010242953896523-0.005389360245317221j), (-0.011277255602180958-0.009255425073206425j), (-0.007929397746920586-0.011867750436067581j), (-0.0037841922603547573-0.012475799769163132j), (2.3712178176538146e-07-0.01081632450222969j), (0.0022014265414327383-0.007256560493260622j), (0.0018616663292050362-0.0027860498521476984j), (-0.0014106128364801407+0.0011576090473681688j), (-0.007248264271765947+0.003002147190272808j), (-0.0145023874938488+0.0014280482428148389j), (-0.021412136033177376-0.004259611014276743j), (-0.02594444714486599-0.01386830024421215j), (-0.026237111538648605-0.0262382123619318j), (-0.021048320457339287-0.03938060998916626j), (-0.010107523761689663-0.05081949383020401j), (0.005720863584429026-0.05807248502969742j), (0.024510696530342102-0.05917056277394295j), (0.04358147457242012-0.05310191959142685j), (0.05998324230313301-0.04007771238684654j), (0.07105987519025803-0.021554160863161087j), (0.07497094571590424+1.56401586082211e-06j), (0.0710589736700058+0.021557122468948364j), (0.059981569647789+0.04008021205663681j), (0.043579258024692535+0.0531037375330925j), (0.024508226662874222+0.059171583503484726j), (0.0057184407487511635+0.05807271972298622j), (-0.010109644383192062+0.050819072872400284j), (-0.02104996144771576+0.03937973454594612j), (-0.0262382123619318+0.026237111538648605j), (-0.0259450301527977+0.01386721059679985j), (-0.021412314847111702+0.004258712287992239j), (-0.014502327889204025-0.0014286567457020283j), (-0.007248138543218374-0.0030024514999240637j), (-0.0014105642912909389-0.0011576684191823006j), (0.001861549448221922+0.0027861278504133224j), (0.0022011217661201954+0.007256652694195509j), (-2.1674925676506973e-07+0.01081632450222969j), (-0.003784715663641691+0.012475641444325447j), (-0.00792989507317543+0.011867417953908443j), (-0.011277644895017147+0.00925495196133852j), (-0.01301046833395958+0.005388814490288496j), (-0.012814128771424294+0.0012618298642337322j), (-0.010898846201598644-0.002168134320527315j), (-0.007888183929026127-0.0042165168561041355j), (-0.0046164183877408504-0.004616594407707453j), (-0.0018939926521852612-0.0035435729660093784j), (-0.0003031401720363647-0.001524138730019331j), (-7.234830263769254e-05+0.0007344236364588141j), (-0.0010539257200434804+0.002544267801567912j), (-0.002800451125949621+0.003412230871617794j), (-0.004711002577096224+0.0031476656440645456j), (-0.006202818360179663+0.0018814806826412678j), (-0.006861571222543716-1.2449403641312529e-07j), (-0.006533246487379074-0.0019819671288132668j), (-0.005339208524674177-0.003567683743312955j), (-0.00361774698831141-0.00440839771181345j), (-0.0018143157940357924-0.004380364902317524j), (-0.00035411203862167895-0.0035960066597908735j), (0.0004678240802604705-0.0023516961373388767j), (0.0005516558885574341-0.001032032654620707j), (1.2357627538108392e-18-1.2357202574068693e-18j), (-0.0009290619054809213+0.0004965735133737326j), (-0.0019055892480537295+0.0003790116752497852j), (-0.0026223030872642994-0.00025831887614913285j), (-0.002873834455385804-0.0011904375860467553j), (-0.0026010721921920776-0.002134716836735606j), (-0.0018921829760074615-0.002831952879205346j), (-0.0009442918817512691-0.0031130965799093246j), (4.7692246596398036e-08-0.0029352258425205946j), (0.0007220670813694596-0.002380198100581765j), (0.00108256284147501-0.001620113616809249j), (0.0010506502585485578-0.00086221843957901j), (0.000700551550835371-0.00029016498592682183j), (0.00018060281581711024-1.7784970623324625e-05j), (-0.00033426075242459774-6.649400165770203e-05j), (-0.0006919951410964131-0.0003698928339872509j), (-0.0008013682090677321-0.0008013942860998213j), (-0.0006493559340015054-0.001214909483678639j), (-0.00029559223912656307-0.0014861817471683025j), (0.00015205367526505142-0.0015435299137607217j), (0.0005720248445868492-0.0013809135416522622j), (0.0008632485405541956-0.0010518275666981936j), (0.0009697399218566716-0.0006479296716861427j), (0.000890128780156374-0.0002699961478356272j), (0.0006713600596413016+1.539823557550335e-08j), (0.0003902198513969779+0.00011838202772196382j), (0.00012920089648105204+8.633387187728658e-05j), (-4.605443973559886e-05-5.612040695268661e-05j), (-0.00010185642895521596-0.0002459214301779866j), (-4.1033919842448086e-05-0.0004167402512393892j), (0.00010284224845236167-0.0005169474170543253j), (0.00027860564296133816-0.0005211984389461577j), (0.00043345813173800707-0.00043343243305571377j), (0.0005270920810289681-0.00028171594021841884j), (0.000540492357686162-0.0001074930332833901j), (0.00047789071686565876+4.708363121608272e-05j), (0.0003624078235588968+0.00015012822404969484j), (0.00022750052448827773+0.00018671770521905273j), (0.00010708183981478214+0.00016027131641749293j), (2.7034368031308986e-05+8.913174679037184e-05j), (-1.0037436181317756e-23+2.7651913754854074e-19j), (2.416171264485456e-05-7.963984535308555e-05j), (8.561977301724255e-05-0.000128128522192128j), (0.00016318979032803327-0.0001339158188784495j), (0.00023413696908392012-9.697183122625574e-05j), (0.0002794698521029204-2.7513957320479676e-05j), (0.0002877984952647239+5.7259043387603015e-05j), (0.0002572359808254987+0.00013750944344792515j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_0</value></param>
<param><key>value</key><value>1900000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_1</value></param>
<param><key>value</key><value>3750000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_2</value></param>
<param><key>value</key><value>5357000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_3</value></param>
<param><key>value</key><value>7150000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_4</value></param>
<param><key>value</key><value>10125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_5</value></param>
<param><key>value</key><value>14175000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_6</value></param>
<param><key>value</key><value>18118000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_7</value></param>
<param><key>value</key><value>21225000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_filter_taps</value></param>
<param><key>comment</key><value>Fs=640Ksps 32 KHz BW channel filter -10000 10000 stop = 40 taps = 145 transition = 8000</value></param>
<param><key>value</key><value>[(0.0002493603387847543-0j), (0.00022811056987848133+0j), (0.0002059282414847985+0j), (0.00018199831538368016+0j), (0.0001553735783090815+0j), (0.0001250018394785002+0j), (8.975758828455582e-05+0j), (4.8477591917617247e-05+0j), (-1.308664611038187e-19-0j), (-5.6793996918713674e-05-0j), (-0.00012293666077312082-0j), (-0.00019932918075937778-0j), (-0.0002866971481125802-0j), (-0.00038554679485969245-0j), (-0.0004961232771165669-0j), (-0.0006183711811900139-0j), (-0.0007518998463638127-0j), (-0.0008959518163464963-0j), (-0.0010493781883269548-0j), (-0.0012106189969927073-0j), (-0.0013776910491287708-0j), (-0.001548183267004788-0j), (-0.0017192597733810544-0j), (-0.001887670368887484-0j), (-0.002049771137535572-0j), (-0.0022015515714883804-0j), (-0.0023386715911328793-0j), (-0.002456504851579666-0j), (-0.002550191478803754-0j), (-0.002614697441458702-0j), (-0.002644877415150404-0j), (-0.0026355483569204807-0j), (-0.0025815630797296762-0j), (-0.0024778901133686304-0j), (-0.002319693798199296-0j), (-0.002102416940033436-0j), (-0.0018218634650111198-0j), (-0.0014742778148502111-0j), (-0.0010564241092652082-0j), (-0.0005656589055433869-0j), (7.529256946386964e-19+0j), (0.0006418122793547809+0j), (0.0013602608814835548+0j), (0.002155006630346179+0j), (0.0030248539987951517+0j), (0.003967725206166506+0j), (0.004980647005140781+0j), (0.006059750914573669+0j), (0.007200280204415321+0j), (0.008396615274250507+0j), (0.009642308577895164+0j), (0.010930129326879978+0j), (0.012252125889062881+0j), (0.013599691912531853+0j), (0.014963650144636631+0j), (0.01633433625102043+0j), (0.01770169846713543+0j), (0.019055413082242012+0j), (0.02038497105240822+0j), (0.021679820492863655+0j), (0.022929463535547256+0j), (0.024123582988977432+0j), (0.02525216154754162+0j), (0.02630559541285038+0j), (0.027274807915091515+0j), (0.028151359409093857+0j), (0.02892754226922989+0j), (0.029596475884318352+0j), (0.03015219047665596+0j), (0.03058970533311367+0j), (0.030905073508620262+0j), (0.031095443293452263+0j), (0.031159091740846634+0j), (0.031095443293452263+0j), (0.030905073508620262+0j), (0.03058970533311367+0j), (0.03015219047665596+0j), (0.029596475884318352+0j), (0.02892754226922989+0j), (0.028151359409093857+0j), (0.027274807915091515+0j), (0.02630559541285038+0j), (0.02525216154754162+0j), (0.024123582988977432+0j), (0.022929463535547256+0j), (0.021679820492863655+0j), (0.02038497105240822+0j), (0.019055413082242012+0j), (0.01770169846713543+0j), (0.01633433625102043+0j), (0.014963650144636631+0j), (0.013599691912531853+0j), (0.012252125889062881+0j), (0.010930129326879978+0j), (0.009642308577895164+0j), (0.008396615274250507+0j), (0.007200280204415321+0j), (0.006059750914573669+0j), (0.004980647005140781+0j), (0.003967725206166506+0j), (0.0030248539987951517+0j), (0.002155006630346179+0j), (0.0013602608814835548+0j), (0.0006418122793547809+0j), (7.529256946386964e-19+0j), (-0.0005656589055433869-0j), (-0.0010564241092652082-0j), (-0.0014742778148502111-0j), (-0.0018218634650111198-0j), (-0.002102416940033436-0j), (-0.002319693798199296-0j), (-0.0024778901133686304-0j), (-0.0025815630797296762-0j), (-0.0026355483569204807-0j), (-0.002644877415150404-0j), (-0.002614697441458702-0j), (-0.002550191478803754-0j), (-0.002456504851579666-0j), (-0.0023386715911328793-0j), (-0.0022015515714883804-0j), (-0.002049771137535572-0j), (-0.001887670368887484-0j), (-0.0017192597733810544-0j), (-0.001548183267004788-0j), (-0.0013776910491287708-0j), (-0.0012106189969927073-0j), (-0.0010493781883269548-0j), (-0.0008959518163464963-0j), (-0.0007518998463638127-0j), (-0.0006183711811900139-0j), (-0.0004961232771165669-0j), (-0.00038554679485969245-0j), (-0.0002866971481125802-0j), (-0.00019932918075937778-0j), (-0.00012293666077312082-0j), (-5.6793996918713674e-05-0j), (-1.308664611038187e-19-0j), (4.8477591917617247e-05+0j), (8.975758828455582e-05+0j), (0.0001250018394785002+0j), (0.0001553735783090815+0j), (0.00018199831538368016+0j), (0.0002059282414847985+0j), (0.00022811056987848133+0j), (0.0002493603387847543+0j)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ddc_decim</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>640000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_downconv</value></param>
<param><key>value</key><value>8000</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_2</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_0_3</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_1_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_1_1</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_1_2</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_2</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_1_3</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>32767</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>50.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>maxoutbuf</key><value>8192</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>54321</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>62345</value></param>
<param><key>type</key><value>float</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0_2</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_2</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_0_0_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_0_1_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_1_0</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_2</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_1_3</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1</value></param>
<param><key>decim</key><value>audio_decim</value></param>
<param><key>taps</key><value>audio_usb_taps_voice_0</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>audio_bpf_voice</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>ale_chan_01AHFN - center_freq_0</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>ale_chan_03AHFN - center_freq_1</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0</value></param>
<param><key>center_freq</key><value>ale_chan_07AHFN - center_freq_3</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0</value></param>
<param><key>center_freq</key><value>ale_chan_21AHFN - center_freq_7</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0</value></param>
<param><key>center_freq</key><value>ale_chan_21BHFL - center_freq_7</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_1</value></param>
<param><key>center_freq</key><value>ale_chan_07BHFL - center_freq_3</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_1_0</value></param>
<param><key>center_freq</key><value>ale_chan_07CHFL - center_freq_3</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_1</value></param>
<param><key>center_freq</key><value>ale_chan_14AHFN - center_freq_5</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_1_0</value></param>
<param><key>center_freq</key><value>ale_chan_14BHFL - center_freq_5</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_2</value></param>
<param><key>center_freq</key><value>ale_chan_03BHFL - center_freq_1</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_3</value></param>
<param><key>center_freq</key><value>ale_chan_03CHFL - center_freq_1</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>center_freq</key><value>ale_chan_05AHFN - center_freq_2</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_0</value></param>
<param><key>center_freq</key><value>ale_chan_18AHFN - center_freq_6</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_0_0</value></param>
<param><key>center_freq</key><value>ale_chan_18BHFL - center_freq_6</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_1</value></param>
<param><key>center_freq</key><value>ale_chan_05BHFL - center_freq_2</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1_2</value></param>
<param><key>center_freq</key><value>ale_chan_05CHFL - center_freq_2</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_2</value></param>
<param><key>center_freq</key><value>ale_chan_10AHFN - center_freq_4</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_3</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_4</value></param>
<param><key>center_freq</key><value>ale_chan_01BHFL - center_freq_0</value></param>
<param><key>decim</key><value>ddc_decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>channel_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_01AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_03AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_0_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_03BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_0_1</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_03CHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_1</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_05AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_1_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_05BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_1_1</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_05CHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_2</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_07AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_07BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_07CHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_10AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_14AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_14BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_18AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_18BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_21AHFN</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2_0</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_21BHFL</value></param>
</block>
<block>
<key>k6drs_ale2g_rx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale2g_rx_phy_fec_sublayers_0_4</value></param>
<param><key>bad_vote_threshold</key><value>25</value></param>
<param><key>frequency</key><value>ale_chan_01BHFL</value></param>
</block>
<block>
<key>k6drs_ale_2g_tx_phy_fec_sublayers</key>
<param><key>id</key><value>k6drs_ale_2g_tx_phy_fec_sublayers_0</value></param>
<param><key>maxoutbuf</key><value>8192</value></param>
</block>
<block>
<key>k6drs_band_selector</key>
<param><key>id</key><value>k6drs_band_selector_0</value></param>
<param><key>channelBW</key><value>640000</value></param>
</block>
<block>
<key>k6drs_baseband_io</key>
<param><key>id</key><value>k6drs_baseband_io_0</value></param>
<param><key>hostname</key><value>192.168.0.225</value></param>
<param><key>listen_addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12347</value></param>
</block>
<block>
<key>k6drs_command_decoder</key>
<param><key>id</key><value>k6drs_command_decoder_0</value></param>
<param><key>center_frequency</key><value>center_freq_0</value></param>
</block>
<block>
<key>k6drs_portaudio</key>
<param><key>id</key><value>k6drs_portaudio_0</value></param>
<param><key>sample_rate</key><value>8000</value></param>
</block>
<block>
<key>k6drs_sideband_selector</key>
<param><key>id</key><value>k6drs_sideband_selector_0</value></param>
</block>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_0_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_0_0_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_0_1</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_0_1_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_1</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_1_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_2</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_0_3</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_1</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_1_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_1_0_0</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_1_1</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_1_2</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_2</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_1_3</source_block_id><sink_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>k6drs_portaudio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1</source_block_id><sink_block_id>k6drs_command_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>k6drs_baseband_io_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0_2</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_2</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_0_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_1_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_2</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_1_3</source_block_id><sink_block_id>blocks_complex_to_real_0_0_1_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_1_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_1_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_2</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_3</source_block_id><sink_block_id>fft_filter_xxx_0_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_1</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1_2</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_2</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_3</source_block_id><sink_block_id>k6drs_sideband_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_4</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_1_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_2_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_0_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_1_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_3_2_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale2g_rx_phy_fec_sublayers_0_4</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>rx_message</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_ale_2g_tx_phy_fec_sublayers_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_band_selector_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_3</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_1_0</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1_0_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>k6drs_baseband_io_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_3</sink_block_id><source_key>cmd_out</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>k6drs_ale_2g_tx_phy_fec_sublayers_0</sink_block_id><source_key>cmd_out</source_key><sink_key>ale_tx_message</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>k6drs_band_selector_0</sink_block_id><source_key>cmd_out</source_key><sink_key>control_message</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>k6drs_baseband_io_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>k6drs_portaudio_0</sink_block_id><source_key>cmd_out</source_key><sink_key>cmd</sink_key></connection>
<connection><source_block_id>k6drs_command_decoder_0</source_block_id><sink_block_id>k6drs_sideband_selector_0</sink_block_id><source_key>cmd_out</source_key><sink_key>control_message</sink_key></connection>
<connection><source_block_id>k6drs_portaudio_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>tx_complete_event</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>k6drs_sideband_selector_0</source_block_id><sink_block_id>fft_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
